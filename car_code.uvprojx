# Keil uVision project car_code.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car_code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\device_code;.\hal_code;.\niming;.\MPU6050;.\MPU6050\DMP;.\MPU6050\IIC;.\MPU6050\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
  group device
    ./device_code/: bluetooth.c encoder.c PID.c SysTick.c usart.c led.c K210.c motor.c tracking.c ultrasonic.c
  group hal
    ./hal_code/: AI_Hal.c communication.c console.c data_logger.c Ser_Hal.c drive.c
  group MPU6050
    ./MPU6050/: MPU6050.c
    ./MPU6050/sys/: sys.c
    ./MPU6050/IIC/: IIC.c
    ./MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
